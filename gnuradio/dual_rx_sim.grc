<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dual_rx_sim</value></param>
<param><key>title</key><value>Dual RX Simulator</value></param>
<param><key>author</key><value>SM0SVX</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bw</value></param>
<param><key>label</key><value>Bw</value></param>
<param><key>value</key><value>16000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>AF Gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>5,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx1_att</value></param>
<param><key>label</key><value>Rx1 Attenuation</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>100.0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,0,1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx2_att</value></param>
<param><key>label</key><value>Rx2 Attenuation</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>100.0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,2,1,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mod_fq</value></param>
<param><key>label</key><value>Mod Fq</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>7000</value></param>
<param><key>num_steps</key><value>70</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,3,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>swing</value></param>
<param><key>label</key><value>Swing</value></param>
<param><key>value</key><value>3000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,1,1,1</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>device_name</key><value>plughw:0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>mod_source</value></param>
<param><key>label</key><value>Mod Source</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0, 1, 2, 3]</value></param>
<param><key>labels</key><value>["Mic","TX","Noise","Tone"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>7,0,1,1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1/(10**(rx1_att/20))</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0.001</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1/(10**(rx2_att/20))</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>bw/2</value></param>
<param><key>width</key><value>1500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>48000</value></param>
<param><key>tau</key><value>500e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>mod_fq</value></param>
<param><key>amp</key><value>swing/5000.0</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>5500</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>swing/5000.0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>10001</value></param>
<param><key>psize</key><value>4096</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>mod_source</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>TX Audio</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>8,2,2,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>bw/2</value></param>
<param><key>width</key><value>1500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Rx1 Audio</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>8,0,2,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>48000</value></param>
<param><key>tau</key><value>500e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>bw/2</value></param>
<param><key>width</key><value>1500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>48000</value></param>
<param><key>tau</key><value>500e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Rx2 Audio</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>8,2,2,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Rx1 Baseband</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>600,100</value></param>
<param><key>grid_pos</key><value>0,0,5,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Rx2 Baseband</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>600,100</value></param>
<param><key>grid_pos</key><value>0,2,5,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>10000</value></param>
<param><key>psize</key><value>4096</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>device_name</key><value>plughw:0</value></param>
</block>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_1</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>wxgui_fftsink2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>analog_nbfm_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
