options:
  parameters:
    author: SM0SVX
    generate_options: qt_gui
    id: trx_sim
    output_language: python
    title: Trx Simulation
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-50'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: audio_input
  id: variable_qtgui_chooser
  parameters:
    label: Input Select
    label0: Generator
    label1: File
    label2: Mike
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: noise_level
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: tone_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-50'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: tone_fq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50'
    step: '10'
    stop: '7000'
    value: '1000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: pow(10, (noise_level+30)/20)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: pow(10, tone_amp/20)
    freq: tone_fq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: sysdefault
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: sysdefault
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_short_0_1_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: '2'
    offset: '0'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(10, audio_gain/20)
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_input
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[1, 1]'
    type: float
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '9000'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '9001'
    psize: '4096'
    type: short
    vlen: '1'
  states: {}
- name: file
  id: parameter
  parameters:
    label: File
    short_id: f
    type: str
    value: /dev/zero
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-110'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    size: '8192'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [audio_source_0, '0', blocks_selector_0, '2']
- [blocks_add_xx_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0, '0', blocks_selector_0, '1']
- [blocks_float_to_short_0_1_0, '0', blocks_udp_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_short_to_float_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_stream_mux_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_stream_mux_0, '1']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_short_to_float_0, '0', audio_sink_0, '0']
- [blocks_short_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_mux_0, '0', blocks_float_to_short_0_1_0, '0']
- [blocks_udp_source_0, '0', blocks_keep_m_in_n_0, '0']

metadata:
  file_format: 1
